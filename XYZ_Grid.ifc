Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, SurfaceGeometryAddOnView], Option [Elements to export: Visible elements (on all stories)], Option [Partial Structure Display: Entire Model], Option [IFC Domain: All], Option [Structural Function: All Elements], Option [Convert Grid elements: On], Option [Convert IFC Annotations and ARCHICAD 2D elements: Off], Option [Convert 2D symbols of Doors and Windows: Off], Option [Export geometries that Participates in Collision Detection only: On], Option [Split complex elements: Off], Option [Material Preservation: Explode where necessary], Option [IFC Site Location: At Project Origin], Option [Curtain Wall export mode: Single Element], Option [Railing export mode: Single Element], Option [Stair export mode: Single Element], Option [Properties To Export: All properties], Option [Space containment: Off], Option [Bounding Box: Off], Option [Geometry to type objects: Off], Option [Element Properties: Off], Option [Building Material Properties: Off], Option [Element Parameters: Off], Option [Component Parameters: Off], Option [IFC Base Quantities: Off], Option [Door Window Parameters: On], Option [IFC Space boundaries: Off], Option [ARCHICAD Zone Categories as IFC Space classification data: Off], Option [Element Classifications: Off]
File name: C:\Users\A006366\Desktop\XYZGrid.ifc
Time: 2023-02-24T14:19:44
Author: Architect
Organization: Building Designer Office
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: IFC file generated by GRAPHISOFT ARCHICAD 24.0.0 JPN FULL Windows version (IFC add-on version: 6004 JPN FULL).
Authorization: The authorising person

# IfcSite, サイト
RefLatitude: 35, 42, 0, 0; RefLongitude: 139, 46, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, 1FL
In: 建築
Elevation: 0 mm

# IfcBuildingElementProxy: 一般 (12)
In: 1FL
Material: 一般
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
